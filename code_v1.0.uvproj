# Keil uVision project code_v1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: code_v1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\application;.\driver;.\porting
  group application
    ./application/: main.c main.h app_task.c app_task.h app_fans.c app_fans.h app_disp.c app_disp.h app_music.c app_music.h
  group porting
    ./porting/: button_porting.c buzzer_porting.c
  group driver
    ./driver/: delay.c button.c buzzer.c Nixie.c OneWire.c DS18B20.c timer.c timer.h IR.c Timer0.c Int1.c eeprom.c eeprom.h
  group Source Group 1
    ./: STARTUP.A51
