# Keil uVision project main.uvproj, settings and files
target main (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: main
  BeforeMake: powershell -NoProfile -ExecutionPolicy Bypass -File "$Pbuild_c_abs.ps1"
  c flags: Optimize=8 SizeSpeed=1
  c include: .\application;.\driver;.\porting
  group source
    ./: main.c
target main_dbg (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: main_dbg
  BeforeMake: powershell -NoProfile -ExecutionPolicy Bypass -File "$Pbuild_c_abs.ps1" -Debug
  c flags: Optimize=8 SizeSpeed=1
  c include: .\application;.\driver;.\porting
target main_irdiag (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: main_irdiag
  BeforeMake: powershell -NoProfile -ExecutionPolicy Bypass -File "$Pbuild_c_abs.ps1" -Ir
  c flags: Optimize=8 SizeSpeed=1
  c include: .\application;.\driver;.\porting
target us_scope (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: us_scope
  BeforeMake: powershell -NoProfile -ExecutionPolicy Bypass -File "$Pbuild_c_abs.ps1" -Scope
  c flags: Optimize=8 SizeSpeed=1
  c include: .\application;.\driver;.\porting
